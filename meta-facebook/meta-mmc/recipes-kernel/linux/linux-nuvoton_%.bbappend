FILESEXTRAPATHS:prepend := "${THISDIR}/linux-nuvoton:"
SRC_URI:append = " file://mmc.cfg \
           "
